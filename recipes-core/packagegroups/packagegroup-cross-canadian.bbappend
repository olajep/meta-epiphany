## add in the epiphany-elf build tools
## todo for later epiphany-elf-gdb-cross-canadian-epiphany
RDEPENDS_${PN} += "\
    binutils-cross-canadian-epiphany \
    gcc-cross-canadian-epiphany \
"

