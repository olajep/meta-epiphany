

## add in the epiphany-sdk component
RDEPENDS:${PN} += "\
    nativesdk-epiphany-sdk \
"

