require epiphany-sdk_1.0.inc
